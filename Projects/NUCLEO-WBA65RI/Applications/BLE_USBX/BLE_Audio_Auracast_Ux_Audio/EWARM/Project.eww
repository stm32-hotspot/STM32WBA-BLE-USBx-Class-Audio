<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\BLE_Audio_Auracast_Ux_Audio.ewp</path>
  </project>
  <batchBuild />
</workspace>
